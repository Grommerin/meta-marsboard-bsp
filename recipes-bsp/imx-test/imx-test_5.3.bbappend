
COMPATIBLE_MACHINE = "(mx6|mx6ul|mx7|marsboard)"
